# Keil uVision project YC3121_Keil.uvprojx, settings and files
target YC3121 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: YC3121_Keil +hex
  AfterMake: fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  AfterMake: .\..\..\..\hex_to_bin\genbin.bat
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USEKEILCOMPILE__
  c include: ..\..\..\..\..\Librarier\core;..\..\..\..\..\Librarier\sdk
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\YC3121_keil.sct
  group core
    ../../../../../Librarier/core/: misc.c system.c
  group main
    ../../user/: main.c
    ../../../../../Librarier/core/: bt_code.c
  group sdk
    ../../../../../Librarier/sdk/: yc_gpio.c yc_uart.c yc_encflash_bulk.lib yc_qspi.lib yc_otp.c yc_systick.c yc_timer.c
  group startup
    ../../../../../Librarier/startup/: flash_start.s startup.s
