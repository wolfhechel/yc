# Keil uVision project YC3121_Keil.uvprojx, settings and files
target YC3121 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: YC3121_Keil +hex
  AfterMake: fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  c flags: Optim=4 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __USEKEILCOMPILE__
  c include: ..\..\..\..\..\Librarier\core;..\..\..\..\..\Librarier\sdk;..\..\..\..\..\Librarier\sdk\yc_usb\libraries\harward_Der;..\..\..\..\..\Librarier\sdk\yc_usb\libraries\SCPU_USB_Device_Library\core;..\..\..\..\..\Librarier\sdk\yc_usb\scpu_usb_CDC_Device_Demo;..\..\..\..\..\Librarier\sdk\yc_usb\libraries\SCPU_USB_Device_Library\class\CDC;..\..\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Objects\YC3121_keil.sct
  group core
    ../../../../../Librarier/core/: misc.c system.c bt_code.c
  group main
    ../../user/: main.c
  group sdk
    ../../../../../Librarier/sdk/: yc_gpio.c yc_uart.c yc_timer.c yc_ipc.c yc_lpm.c yc_otp.c yc_sysctrl.c
  group startup
    ../../../../../Librarier/startup/: flash_start.s startup.s
  group yc_usb\libraries\harward_Der
    ../../../../../Librarier/sdk/yc_usb/libraries/harward_Der/: usb_core.c Usb_dcd.c
    ../../../../../Librarier/sdk/yc_usb/scpu_usb_CDC_Device_Demo/: usb_bsp.c
  group yc_usb\libraries\SCPU_USB_Device_Library\core
    ../../../../../Librarier/sdk/yc_usb/libraries/SCPU_USB_Device_Library/core/: usbd_core.c usbd_req.c usbd_ioreq.c
  group yc_usb\libraries\SCPU_USB_Device_Library\class\cdc
    ../../../../../Librarier/sdk/yc_usb/libraries/SCPU_USB_Device_Library/class/CDC/: usbd_cdc_core.c
    ../../../../../Librarier/sdk/yc_usb/scpu_usb_CDC_Device_Demo/: usbd_cdc_vcp.c
  group yc_usb\scpu_usb_cdc_Device_Demo
    ../../../../../Librarier/sdk/yc_usb/scpu_usb_CDC_Device_Demo/: Usb_dcd_init.c usb_main.c usbd_desc.c usbd_usr.c
