# Keil uVision project YC3121_Keil.uvprojx, settings and files
target YC3121 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: YC3121_Keil +hex
  AfterMake: fromelf.exe --text -a -c --output=@L_asm.txt "!L"
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: __USEKEILCOMPILE__
  c include: ..\..\..\..\..\Librarier\sdk;..\..\..\..\..\Librarier\core;..\..\user\uCOS-II\Ports;..\..\user\uCOS-II\Source;..\..\user
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: ..\..\..\..\..\ConfigFiles\MDK\YC3121_keil.sct
  group core
    ../../../../../Librarier/core/: system.c misc.c
  group main
    ../../user/: main.c yc_os_middle.c
  group sdk
    ../../../../../Librarier/sdk/: yc_uart.c yc_gpio.c yc_timer.c yc_systick.c yc_sysctrl.c
  group startup
    ../../../../../Librarier/startup/: flash_start.s startup.s
  group ucos-port
    ../../user/uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c os_cpu.h
  group ucos-source
    ../../user/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group app
    ../../user/: os_cfg.h
