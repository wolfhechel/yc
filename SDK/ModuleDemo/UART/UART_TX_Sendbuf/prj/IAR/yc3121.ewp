# IAR project yc3121.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\user; ..\..\..\..\..\Librarier\core; ..\..\..\..\..\Librarier\sdk
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: yc3121.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: yc3121.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ../../user/: main.c
  group core
    ../../../../../Librarier/core/: misc.c system.c type.h
  group sdk
    ../../../../../Librarier/sdk/: yc_gpio.c yc_uart.c
  group startup
    ../../../../../Librarier/startup/: flash_start_iar.s
