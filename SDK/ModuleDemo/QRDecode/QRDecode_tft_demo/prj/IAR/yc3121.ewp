# IAR project yc3121.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa039,Pa082,Pe606
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\demo\ModuleDemo\QRDecode\QRDecode_tft_demo\user; ..\..\..\..\..\..\demo\Librarier\core; ..\..\..\..\..\..\demo\Librarier\sdk; ..\..\..\..\..\..\demo\Librarier\sdk\yc_qr
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: yc3121.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: yc3121.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group core
    ../../../../../Librarier/core/: misc.c system.c type.h
  group main
    ../../user/: font.c main.c
  group qr
    ../../../../../Librarier/sdk/yc_qr/: YC_QRDecode.h YC_QRDecode_lib_IAR.a YC_QRDecode_TypeDef.h
  group sdk
    ../../../../../Librarier/sdk/: yc_gpio.c yc_iic.c yc_ipc.c yc_kscan.c yc_lpm.c yc_otp.c yc_spi.c yc_st7789.c yc_sysctrl.c yc_timer.c yc_uart.c
  group startup
    ../../../../../Librarier/startup/: flash_start_iar.s
